Commit message: updated urdf with mesh 1

File: xacro/delta.urdf (robot description, URDF)
Before this commit: robot robot, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=package://smartrobotcell/meshes/triskelion_2_mini.stl scale=0.001 0.001 0.001
